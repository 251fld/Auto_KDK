## boards/shields/43wireless1/Kconfig.defconfig
```kconfig
if SHIELD_43WIRELESS1

config ZMK_KEYBOARD_NAME
    default "43wireless1"

endif
```
